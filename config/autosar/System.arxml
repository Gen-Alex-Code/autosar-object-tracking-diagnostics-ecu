<!-- AUTOSAR-inspired system model placeholder -->
<AUTOSAR>
</AUTOSAR>
